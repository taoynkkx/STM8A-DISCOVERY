# IAR project stm8af_discover.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8AF5288 STM8AF5288
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8AF52Ax
  ICCSTM8.CCDiagSuppress: Pa091
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: stm8af_discover.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8S_StdPeriph_Driver/inc
    ../../../Libraries/STM8S_StdPeriph_Driver/inc/: stm8s_adc2.h stm8s_can.h stm8s_clk.h stm8s_exti.h stm8s_gpio.h stm8s_spi.h stm8s_tim4.h stm8s_uart3.h
  group STM8S_StdPeriph_Driver/src
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc2.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_spi.c stm8s_tim4.c stm8s_uart3.c
  group User/inc
    ../inc/: adc.h appli.h can.h L99PM62drv.h L99PM62drv_AL.h L99PM62drv_Cfg.h lin.h main.h stm8s.h stm8s_conf.h stm8s_it.h
  group User/src
    ../src/: adc.c appli.c can.c L99PM62drv.c lin.c main.c stm8s_it.c
