# IAR project stm8al_discover.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8AL3L68 STM8AL3L68
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCDiagSuppress: Pa091
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: stm8al_discover.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8L15x_StdPeriph_Driver/inc
    ../../../Libraries/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_clk.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_itc.h stm8l15x_lcd.h stm8l15x_spi.h stm8l15x_tim4.h stm8l15x_usart.h
  group STM8L15x_StdPeriph_Driver/src
    ../../../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_lcd.c stm8l15x_spi.c stm8l15x_tim4.c stm8l15x_usart.c
  group User/inc
    ../inc/: appli.h delay.h discover_functions.h icc_measure.h L99PM62drv.h L99PM62drv_AL.h L99PM62drv_Cfg.h lcd.h lin.h lowpower.h main.h stm8al-discovery.h stm8l15x_conf.h stm8l15x_it.h
  group User/src
    ../src/: appli.c delay.c discover_functions.c icc_measure.c L99PM62drv.c lcd.c lin.c lowpower.c main.c stm8l15x_it.c
    ./: eeprom_itf.c
